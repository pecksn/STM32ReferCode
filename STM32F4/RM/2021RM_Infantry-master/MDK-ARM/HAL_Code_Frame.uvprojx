# Keil uVision project HAL_Code_Frame.uvprojx, settings and files
target HAL_Code_Frame (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: HAL_Code_Frame +hex
  AfterMake: fromelf --bin --output .\HAL_Code_Frame\HAL_Code_Frame.bin .\HAL_Code_Frame\HAL_Code_Frame.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,__TARGET_FPU_VFP=1,ARM_MATH_CM4,__CC_ARM
  c include: ../Inc;                                                                  ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                  ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                                  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                                  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                  ../Drivers/CMSIS/Include;                                                                  ..\Algorithm\Algorithm.h;                                                                  ..\Apps\Apps.h;                                                                  ..\BSP\BSP.h;                                                                  ..\Devices\Devices.h;                                                                  ..\Tasks\Tasks.h;                                                                  ..\USER;                                                                  ..\Drivers\CMSIS\DSP\Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c dma.c iwdg.c rng.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Algorithm
    ../Algorithm/Algorithm.c/: AddMath.c CRC.c Parabola.c PID.c SpeedRamp.c USER_Filter.c kalman_filter.c
  group Apps
    ../Apps/Apps.c/: Chassis_control.c Cloud_control.c Control_Vision.c DevicesMonitor.c Monitor_RM_CAN.c PowerLimit.c Robot_control.c Shoot.c Status_Update.c IMU_Compensate.c RMClient_UI.c
  group BSP
    ../BSP/BSP.c/: BSP_CAN.c BSP_TIM.c BSP_USART.c BSP_ADC.c Flash_Store.c PVD.c
  group Devices
    ../Devices/Devices.c/: ANO.c Debug_DataScope.c DR16_Remote.c M2006_Motor.c M3508_Motor.c M6020_Motor.c RM_JudgeSystem.c Snail_Motor.c Wolf_GyIMU.c Laser.c DJI_IMU.c SuperCapacitor.c OLED.c USER_RNG.c DJI_C_IMU.c
  group Tasks
    ../Tasks/Tasks.c/: Task_CanMsg.c Task_DataScope.c Task_DevicesMonitor.c Task_RobotControl.c Task_Sampling.c Task_OLED.c Task_CanSend.c
software components: CMSIS:CORE 5.2.0
